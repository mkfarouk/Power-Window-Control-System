# Keil uVision project project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: D:\ti\TivaWare_C_Series-2.2.0.295;D:\ti\TivaWare_C_Series-2.2.0.295\inc
  asm include: D:\ti\TivaWare_C_Series-2.2.0.295\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c tm4c123gh6pm.h motor.h motor.c
    D:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Device:Startup 1.0.1
